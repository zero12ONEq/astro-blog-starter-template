# Keil uVision project Template.uvproj, settings and files
target Tempate (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: key.c key.h seg.c seg.h led.c led.h init.c init.h ds1302.c ds1302.h onewire.c onewire.h iic.c iic.h ultrasound.c ultrasound.h uart.c uart.h
