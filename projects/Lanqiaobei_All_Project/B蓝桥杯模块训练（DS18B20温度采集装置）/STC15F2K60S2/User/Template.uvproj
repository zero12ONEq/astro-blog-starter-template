# Keil uVision project Template.uvproj, settings and files
target Template (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: init.c init.h key.c key.h seg.c seg.h led.c led.h onewire.c onewire.h
