# Keil uVision project Template_simulation.uvproj, settings and files
target Template_simulation (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Template_simulation +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: key.c key.h Seg.c seg.h led.c led.h
