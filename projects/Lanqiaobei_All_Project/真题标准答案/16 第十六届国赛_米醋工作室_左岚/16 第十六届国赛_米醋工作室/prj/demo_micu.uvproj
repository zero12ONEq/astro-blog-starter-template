# Keil uVision project demo_micu.uvproj, settings and files
target demo_micu (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: demo_micu +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\driver
  group user
    ./: STARTUP.A51
    ../src/user/: main.c
  group driver
    ../src/driver/: key.c led.c seg.c init.c ds1302.c onewire.c iic.c uart.c ultrasound.c
