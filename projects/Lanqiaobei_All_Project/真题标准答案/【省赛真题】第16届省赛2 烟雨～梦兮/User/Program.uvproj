# Keil uVision project Program.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Program +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Ds18b20.c Ds18b20.h Ds1302.c Ds1302.h I2C.c I2C.h Init.c Init.h Key.c Key.h Led.c Led.h Seg.c Seg.h Sonic.c Sonic.h Uart.c Uart.h
